EXTRA_OEMAKE:append = " LOG_LEVEL=LOG_LEVEL_INFO"
EXTRA_OEMAKE:append = " NEED_BL32=yes"
EXTRA_OEMAKE:append = " SPD=opteed"

