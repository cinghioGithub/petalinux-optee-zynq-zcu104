require recipes-security/optee/optee-examples.inc

# v4.4.0
#SRCREV = "378dc0db2d5dd279f58a3b6cb3f78ffd6b165035"

# v4.5.0
SRCREV = "5306d2c7c618bb4a91df17a2d5d79ae4701af4a3"