COMPATIBLE_MACHINE:zynqmp ?= ".*"