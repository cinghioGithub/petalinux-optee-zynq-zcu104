COMPATIBLE_MACHINE:zynqmp ?= ".*"
